# Keil uVision project BeeWatch.uvprojx, settings and files
target BeeWatch (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\inc;..\..\Library\hv_Library;..\..\Library\hv_Library\component;..\..\Library\STM32F1xx_HAL_Driver\Inc;..\..\Library\CMSIS\Include;..\..\Library\CMSIS\Device\ST\STM32F1xx\Include;..\..\Library\FreeRTOS\include;..\..\Library\FreeRTOS\CMSIS_RTOS;..\..\Library\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib/HAL_Driver
    ../../Library/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Lib/CMSIS
    ../../Library/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Lib/hv_driver
    ../../Library/hv_Library/: GPIO.cpp GPIO.h SPI.cpp SPI.h RTC.cpp RTC.h MISC.cpp MISC.h
  group Lib/hv_component
    ../../Library/hv_Library/component/: CC2530.cpp CC2530.h ili9163.cpp ili9163.h Z_stack.cpp Z_stack.h ADXL345.h Graphic.cpp Graphic.h HeartRate.cpp HeartRate.h
  group Lib/FreeRTOS
    ../../Library/hv_Library/component/: ADXL345.cpp
    ../../Library/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Library/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ../../Library/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../Library/FreeRTOS/portable/MemMang/: heap_4.c
  group startup
    ../../Library/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group user
    ../src/: main.cpp stm32f1xx_it.c BeeWatch.cpp
    ../inc/: BeeWatch.h
